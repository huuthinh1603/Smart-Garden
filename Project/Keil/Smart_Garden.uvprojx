# Keil uVision project Smart_Garden.uvprojx, settings and files
target Smart_Garden (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Smart_Garden
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\..\Project;..\..\Lib\CMSIS\CM3\CoreSupport;..\..\Lib\STM32F10x_StdPeriph_Driver\inc;..\..\Lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x\startup\arm;..\Value
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../: main.c stm32f10x_it.c system_stm32f10x.c
  group Lib
    ../../Lib/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Lib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
    ../../Lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_usart.c
